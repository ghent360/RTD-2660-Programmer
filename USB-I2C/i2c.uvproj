# Keil uVision project i2c.uvproj, settings and files
target Target 1 (MCS-51)
  device: EZ-USB FX2LP (CY7C68XXX-X) Cypress Semiconductor
  cpu: IRAM(0-0xFF) XRAM(0xE000-0xE3FF) CLOCK(48000000) MODDP2
  output: i2c +hex
  AfterMake: c:\cypress\usb\bin\hex2bix -i -c 0x00 -f 0xC2 -o i2c.iic i2c.hex
  c flags: Optimize=9 SizeSpeed=1
  group Sources
    ./: STARTUP.A51 USBJmpTb.OBJ dscr.a51 EZUSB.LIB periph.c syncdly.h lp.h lpregs.h i2c.c
